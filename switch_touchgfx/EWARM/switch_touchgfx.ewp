# IAR project switch_touchgfx.ewp, settings and files
configuration switch_touchgfx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_BPP=24
  ICCARM.CCIncludePath2: ../Core/Inc; ../TouchGFX/target; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/gui/include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/BSP/Components/exc7200; ../Drivers/BSP/Components/stmpe811; ../Drivers/BSP/Components/ts3510; ../Drivers/BSP/Components/ampire480272; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/BSP/Components/Common; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: switch_touchgfx.hex
  ILINK.IlinkOutputFile: switch_touchgfx.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c ft5436.c main.cpp persist_storage.c sdram.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp HW_Init.cpp STM32F4DMA.cpp STM32F4HAL.cpp STM32F4Instrumentation.cpp STM32F4TouchController.cpp
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp Font_verdana_10_4bpp.cpp Font_verdana_20_4bpp.cpp Font_verdana_40_4bpp.cpp FontGetters.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: AllScenesContainerBase.cpp AllZonesContainerBase.cpp PanelSettingsContainerBase.cpp SingleZoneContainerBase.cpp WindowSettingsContainerBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/main_screen
    ../TouchGFX/generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: autoTintButtonNotPressedNew.cpp autoTintButtonPressedNew.cpp backButton.cpp background_image.cpp BitmapDatabase.cpp closeButton.cpp combinedGraphicNew.cpp manualTintButtonNotPressedNew.cpp manualTintButtonPressedNew.cpp panelBase.cpp panelSettingsButtonIcon.cpp presentScenesButtonNotPressedNew.cpp presentScenesButtonPressedNew.cpp saintGobainLogo.cpp sliderBase4Points.cpp sliderIndicator.cpp sun-icon.cpp toggleNotPressed.cpp togglePressed.cpp zoneGrad1NotPressed.cpp zoneGrad1Pressed.cpp zoneGrad2NotPressed.cpp zoneGrad2Pressed.cpp zoneGrad3NotPressed.cpp zoneGrad3Pressed.cpp zoneGrad4NotPressed.cpp zoneGrad4Pressed.cpp zoneGrey1NotPressed.cpp zoneGrey1Pressed.cpp zoneGrey2NotPressed.cpp zoneGrey2Pressed.cpp zoneGrey3NotPressed.cpp zoneGrey3Pressed.cpp zoneWhiteNotPressed.cpp zoneWhitePressed.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: AllScenesContainer.cpp AllZonesContainer.cpp PanelSettingsContainer.cpp SingleZoneContainer.cpp WindowSettingsContainer.cpp
  group Application/User/TouchGFX/gui/main_screen
    ../TouchGFX/gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/exc7200/: exc7200.c
    ../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../Drivers/BSP/Components/ts3510/: ts3510.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/TouchGFX
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
    ../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m4f/IAR8.x/: touchgfx_core_release.a
